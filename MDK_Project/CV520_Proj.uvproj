# Keil uVision project CV520_Proj.uvproj, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: CV520_Proj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __DEBUG_FLASH
  c include: ..\Common\inc;..\userinc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source
    ../Common/src/: gpio.c uart.c
  group Startup
    ../Common/src/: core_cm0.c startup_LPC11Uxx.s system_LPC11Uxx.c
  group user
    ../User/: main.c XMODE.c
